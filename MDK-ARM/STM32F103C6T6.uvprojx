# Keil uVision project STM32F103C6T6.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c6t6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c misc: -std=c99 -ffunction-sections -fdata-sections -fno-common -Wextra -Wno-unused-parameter
  c include: ../Core/Include;../App/Include;../Bsp/Include;../external/cubeF1/STM32CubeF1/Drivers/CMSIS/Core/Include;../external/cubeF1/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../external/cubeF1/STM32CubeF1/Drivers/STM32F1xx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: ..\cmake\stm32f103c6tx.sct
  link misc: --datacompressor=off --info=sizes,totals
  group App
    ../App/Src/: app.c ringbuffer.c
  group Bsp
    ../Bsp/Src/: bsp_board.c bsp_diag.c bsp_log.c bsp_fault.c
  group Core
    ../Core/Src/: main.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../external/cubeF1/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../external/cubeF1/STM32CubeF1/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103x6.s
  group Drivers/STM32F1xx_HAL_Driver
    ../external/cubeF1/STM32CubeF1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
target Release (6240000::V6.24::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: stm32f103c6t6 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: ..\cmake\stm32f103c6tx.sct
  link misc: --datacompressor=off --info=sizes,totals
